Commit message: some better heuristics for pose detection

File: assets/hammer.urdf (robot description, URDF)
Before this commit: robot hammer, 1 links, 0 joints
Links:
- link hammer: geometry collision box size=0.02 0.06 0.025; collision cylinder length=0.20 radius=0.014
